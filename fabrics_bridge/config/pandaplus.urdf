Commit message: Debugging panda plus, found error in urdf.

File: fabrics_bridge/config/pandaplus.urdf (robot description, URDF)
Before this commit: robot albert_description, 26 links, 25 joints
Joints:
- joint mobile_joint_x: origin xyz=0 0 0.05 rpy=0 0 0 -> xyz=0 0 0.00 rpy=0 0 0
